## base_external/package/servo-driver/Config.in
```kconfig
config BR2_PACKAGE_SERVO_DRIVER
	bool "servo-driver"
	help
	  Module and application code for a servo driver
```
